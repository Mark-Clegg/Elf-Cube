# Repository Mark-Clegg/Elf-Cube

File README.md:

# Elf-Cube
Simple retro computer based on the 1802 series of processors.

Four PCB's are currently in the works

- Backplane
Can host 5 separate I/O cards, and includes the circuitry for the master clock signal and power on reset. It also acts as the main power source for 
any attached cards, which can be supplied via 5.5mm jack, or USB. In addition, the D+/D- signals from the USB connector are also made available to 
slot 1 pins 15 and 34. If more than 5 slots are required, multiple backplanes can be slotted together, populating the additional cards with just the 
connectors. With a 4 MHz oscillator, the system clock is jumper selectable between 1,2 and 4 MHz.

- Processor card
Holds the main CPU, and 2 x 32K RAM/ROM sockets. Jumpers next to each memory socket select ROM/RAM by connecting the ~MWR line, or tying high pin 27
Q and ~EF4 are also routed to an additional 6 pin connector for bit banged serial support. (EF4 can be disconnected via a jumper, and also connected 
to ~interrupt via a jumper)

- IDE Interface
Connects an SD/IDE adapter via a standard IDE 40 pin connector.

- Prototype Adapter
Plugs into a standard breadboard and connects to the backplane via a short ribbon cable, extending the system bus for prototyping activities.

# Software
The Elf^3 Backplane and Processor Card has been tested with the Idiot4 monitor assembled ORG'd at 0000h, using EF4 with EFHI=0 and Q=1. Test code indicates that the IDE interface works as expected.

See the WiKi for more information.

## KiCad design UART Card/UART Card.kicad_pcb

Parts:
C1: 10uF; CP_Radial_D5.0mm_P2.50mm
C2, C3, C4, C5: 1uF; CP_Radial_D5.0mm_P2.50mm
C6, C7, C8, C9, C10, C11: 100nF; C_Disc_D3.8mm_W2.6mm_P2.50mm
C12: 330nf; C_Rect_L7.0mm_W3.5mm_P5.00mm
H1, H2: Mounting Hole; MountingHole_3.2mm_M3_Pad_Via
J1: Conn_02x20_Odd_Even; PinHeader_2x20_P2.54mm_Horizontal
J2: DB9_ Male; DSUB-9_Male_Horizontal_P2.77x2.84mm_EdgePinOffset9.90mm_Hou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
JP1: Baud Select; PinHeader_2x05_P2.54mm_Vertical
JP2: USB; PinHeader_1x02_P2.54mm_Vertical
JP3: ~Interrupt; PinHeader_1x02_P2.54mm_Vertical
JP4: ~EF4; PinHeader_1x02_P2.54mm_Vertical
R1, R2: 47K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
U1: 74LS00; DIP-14_W7.62mm
U2: MAX232; DIP-16_W7.62mm
U3: CDP1854AE; DIP-40_W15.24mm_Socket; Manufacturer_Part_Number CDP1854AE; Mouser Part Number N/A
U4: 74LS393; DIP-14_W7.62mm
U5: 74LS157; DIP-16_W7.62mm
U6: MCP2221AxP; DIP-14_W7.62mm
X1: CXO_DIP8; Oscillator_DIP-8

Connections:
/19200: JP1.1, JP1.3, JP1.5, JP1.7, JP1.9, U3.17, U3.40
/CTS: J2.8, U2.8 (R2IN)
/DTR: C2.1, J2.4, U2.2 (VS+)
/RTS: J2.7, U2.7 (T2OUT)
/RX: J2.2, U2.13 (R1IN)
/TX: J2.3, U2.14 (T1OUT)
CLOCK: J1.4
D0: J1.24, U3.12, U3.26
D1: J1.23, U3.11, U3.27
D2: J1.22, U3.10, U3.28
D3: J1.21, U3.9, U3.29
D4: J1.20, U3.8, U3.30
D5: J1.19, U3.7, U3.31
D6: J1.18, U3.6, U3.32
D7: J1.17, U3.5, U3.33
GND: C1.2, C5.1, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, H1.1, H2.1, J1.39, J1.40, J2.5, JP2.2, U1.7 (GND), U2.15 (GND), U3.3, U4.7 (GND), U4.12 (MR), U5.3 (I1a), U5.8 (GND), U5.15 (E), U6.14 (VSS), X1.4 (GND)
High: R1.2, U3.23, U3.35, U3.37, U3.38, U5.10 (I1c), U5.11 (I0c), U5.13 (I1d), U5.14 (I0d)
unnamed: C3.1, U2.1 (C1+)
unnamed: C3.2, U2.3 (C1-)
unnamed: C4.1, U2.4 (C2+)
unnamed: C4.2, U2.5 (C2-)
unnamed: C5.2, U2.6 (VS-)
unnamed: C12.1, U6.11 (VUSB)
unnamed: JP1.2, U1.4, U4.5 (Q2), U4.13 (CP)
unnamed: JP1.4, U4.11 (Q0)
unnamed: JP1.6, U4.10 (Q1)
unnamed: JP1.8, U4.9 (Q2)
unnamed: JP1.10, U4.8 (Q3)
unnamed: JP2.1, R2.2, U1.12, U1.13
unnamed: JP3.2, U3.13
unnamed: JP4.2, U1.11, U5.1 (S)
unnamed: U1.1, U1.2, U1.6
unnamed: U1.3, U4.2 (MR)
unnamed: U1.5, U4.4 (Q1)
unnamed: U1.8, U2.10 (T2IN)
unnamed: U1.9, U1.10, U3.19
unnamed: U2.9 (R2OUT), U5.2 (I0a)
unnamed: U2.11 (T1IN), U3.25, U6.5 (URx)
unnamed: U2.12 (R1OUT), U5.5 (I0b)
unnamed: U3.20, U5.7 (Zb)
unnamed: U3.39, U5.4 (Za)
unnamed: U4.1 (CP), X1.5 (OUT)
unnamed: U5.6 (I1b), U6.6 (UTx)
Q: J1.7, U3.16
SC0: J1.11
SC1: J1.9
TPA: J1.14
TPB: J1.16, U3.18
USB_D+: J1.15, U6.13 (D+)
USB_D-: J1.34, U6.12 (D-)
VCC: C1.1, C2.2, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, J1.1, J1.2, R1.1, R2.1, U1.14 (VCC), U2.16 (VCC), U3.1, U3.2, U4.14 (VCC), U5.16 (VCC), U6.1 (VDD), X1.8 (Vcc)
~CLEAR: J1.5, U3.21, U6.4 (~RST)
~DMA_IN: J1.6
~DMA_OUT: J1.8
~EF1: J1.35
~EF2: J1.36
~EF3: J1.37
~EF4: J1.38, JP4.1
~INTERRUPT: J1.10, JP3.1
~IOR: J1.26
~IOW: J1.25
~MRD: J1.13, U3.34
~MWR: J1.12
~N1: J1.33
~N2: J1.32
~N3: J1.31, U3.4
~N4: J1.30
~N5: J1.29
~N6: J1.28
~N7: J1.27
~WAIT: J1.3

Board: 2 copper layers, 100.0 x 100.0 mm, 29 parts (0 on the bottom side), 52 nets.

## KiCad design IDE Interface/IDE Interface.kicad_pcb

Parts:
C1: 10uF; CP_Radial_D5.0mm_P2.50mm
C2, C3, C4, C5: 100nF; C_Disc_D3.8mm_W2.6mm_P2.50mm
D1: LED; LED_D3.0mm_Horizontal_O1.27mm_Z2.0mm
H1, H2: Mounting Hole; MountingHole_3.2mm_M3_Pad_Via
J1: Conn_02x20_Odd_Even; PinHeader_2x20_P2.54mm_Horizontal
J2: Conn_02x20_Odd_Even; PinSocket_2x20_P2.54mm_Horizontal
J3: Conn_01x02_Male; PinHeader_1x02_P2.54mm_Horizontal
R1: 470R; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R2: 1K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
U1: 74LS04; DIP-14_W7.62mm
U2: 74LS32; DIP-14_W7.62mm
U3: 74LS245; DIP-20_W7.62mm
U4: 74LS75; DIP-16_W7.62mm

Connections:
CLOCK: J1.4
D0: J1.24, U3.11 (B7)
D1: J1.23, U3.12 (B6)
D2: J1.22, U3.13 (B5)
D3: J1.21, U3.14 (B4)
D4: J1.20, U3.15 (B3)
D5: J1.19, U3.16 (B2)
D6: J1.18, U3.17 (B1)
D7: J1.17, U3.18 (B0)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, H1.1, H2.1, J1.39, J1.40, J2.2, J2.19, J2.22, J2.24, J2.26, J2.28, J2.30, J2.40, J3.2, U1.1, U1.3, U1.5, U1.7 (GND), U1.9, U2.7 (GND), U3.10 (GND), U3.19 (CE), U4.12 (GND)
IDE_A0: J2.35, U4.16 (Q0)
IDE_A1: J2.33, U4.15 (Q1)
IDE_A2: J2.36, U4.10 (Q2)
IDE_D0: J2.17, U3.9 (A7), U4.2 (D0)
IDE_D1: J2.15, U3.8 (A6), U4.3 (D1)
IDE_D2: J2.13, U3.7 (A5), U4.6 (D2)
IDE_D3: J2.11, U3.6 (A4), U4.7 (D3)
IDE_D4: J2.9, U3.5 (A3)
IDE_D5: J2.7, U3.4 (A2)
IDE_D6: J2.5, U3.3 (A1)
IDE_D7: J2.3, U3.2 (A0)
IDE_D8: J2.4
IDE_D9: J2.6
IDE_D10: J2.8
IDE_D11: J2.10
IDE_D12: J2.12
IDE_D13: J2.14
IDE_D14: J2.16
IDE_D15: J2.18
IDE_DMARQ: J2.21
IDE_INTRQ: J2.31
IDE_IORDY: J2.27
unnamed: D1.2 (A), R1.2
unnamed: R2.2, U2.9, U2.10
unnamed: U1.10, U4.4 (E23), U4.13 (E01)
unnamed: U1.11, U2.6
unnamed: U1.12, U3.1 (A->B)
Q: J1.7
SC0: J1.11
SC1: J1.9
TPA: J1.14
TPB: J1.16
USER1: J1.34
USER2: J1.15
VCC: C1.1, C2.1, C3.1, C4.1, C5.1, J1.1, J1.2, J3.1, R1.1, R2.1, U1.14 (VCC), U2.14 (VCC), U3.20 (VCC), U4.5 (VCC)
~CLEAR: J1.5, J2.1
~DMA_IN: J1.6
~DMA_OUT: J1.8
~EF1: J1.35
~EF2: J1.36
~EF3: J1.37
~EF4: J1.38
~IDE_ACTIVE: D1.1 (K), J2.39
~IDE_CS0: J2.37, U4.9 (Q3)
~IDE_CS1: J2.38, U4.8 (~Q3)
~IDE_DMARK: J2.29
~IDE_IOCS16: J2.32
~IDE_IOR: J2.25, U1.13, U2.11
~IDE_IOW: J2.23, U2.3
~IDE_PDIAG: J2.34
~INTERRUPT: J1.10
~IOR: J1.26, U2.13
~IOW: J1.25, U2.1, U2.5
~MRD: J1.13
~MWR: J1.12
~N1: J1.33, U2.2, U2.12
~N2: J1.32, U2.4
~N3: J1.31
~N4: J1.30
~N5: J1.29
~N6: J1.28
~N7: J1.27
~WAIT: J1.3

Notes on the sheet:
1802 Backplane Connector
IDE Interface Connector
IDE Power Connector
Mounting Holes

Board: 2 copper layers, 100.0 x 100.0 mm, 17 parts (0 on the bottom side), 36 nets.

## KiCad design Processor Card/Processor Card.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C7, C8: 100nF; C_Disc_D3.8mm_W2.6mm_P2.50mm
C9: 10uF; CP_Radial_D5.0mm_P2.50mm
D1: GREEN; LED_D3.0mm_Horizontal_O1.27mm_Z2.0mm
D2: RED; LED_D3.0mm_Horizontal_O1.27mm_Z2.0mm
H1, H2: Mounting Hole; MountingHole_3.2mm_M3_Pad_Via
J1: Serial Port; PinHeader_1x06_P2.54mm_Horizontal
J2: Conn_02x20_Odd_Even; PinHeader_2x20_P2.54mm_Horizontal
JP1, JP2: RAM ROM; PinHeader_1x03_P2.54mm_Vertical
JP3: ~INT; PinHeader_1x02_P2.54mm_Vertical
JP4: ~EF4; PinHeader_1x02_P2.54mm_Vertical
R1, R2: 470R; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R3: 1K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R4: 47K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
U1: 74LS32; DIP-14_W7.62mm
U2: 74LS04
U3, U5: 28C256 / 62256; DIP-28_W15.24mm_Socket
U4: 74LS73; DIP-14_W7.62mm
U6: CDP1802/1806; DIP-40_W15.24mm_Socket
U7: 74LS373; DIP-20_W7.62mm
U8: 74LS138; DIP-16_W7.62mm

Connections:
/A0: U3.10 (A0), U5.10 (A0), U6.25 (MA0), U7.3 (D0)
/A1: U3.9 (A1), U5.9 (A1), U6.26 (MA1), U7.4 (D1)
/A2: U3.8 (A2), U5.8 (A2), U6.27 (MA2), U7.7 (D2)
/A3: U3.7 (A3), U5.7 (A3), U6.28 (MA3), U7.8 (D3)
/A4: U3.6 (A4), U5.6 (A4), U6.29 (MA4), U7.13 (D4)
/A5: U3.5 (A5), U5.5 (A5), U6.30 (MA5), U7.14 (D5)
/A6: U3.4 (A6), U5.4 (A6), U6.31 (MA6), U7.17 (D6)
/A7: U3.3 (A7), U5.3 (A7), U6.32 (MA7), U7.18 (D7)
/A8: U3.25 (A8), U5.25 (A8), U7.2 (O0)
/A9: U3.24 (A9), U5.24 (A9), U7.5 (O1)
/A10: U3.21 (A10), U5.21 (A10), U7.6 (O2)
/A11: U3.23 (A11), U5.23 (A11), U7.9 (O3)
/A12: U3.2 (A12), U5.2 (A12), U7.12 (O4)
/A13: U3.26 (A13), U5.26 (A13), U7.15 (O5)
/A14: U3.1 (A14), U5.1 (A14), U7.16 (O6)
/A15: U2.1, U5.20 (~CS), U7.19 (O7)
/CTS: J1.2, J1.6
/N0: U6.19 (N0), U8.1 (A0)
/N1: U6.18 (N1), U8.2 (A1)
/N2: U6.17 (N2), U8.3 (A2)
/RX: J1.4, R4.2, U1.10
/TX: D2.1 (K), J1.5, U2.6
CLOCK: J2.4, U6.1 (CLOCK)
D0: J2.24, U3.11 (D0), U5.11 (D0), U6.15 (BUS0)
D1: J2.23, U3.12 (D1), U5.12 (D1), U6.14 (BUS1)
D2: J2.22, U3.13 (D2), U5.13 (D2), U6.13 (BUS2)
D3: J2.21, U3.15 (D3), U5.15 (D3), U6.12 (BUS3)
D4: J2.20, U3.16 (D4), U5.16 (D4), U6.11 (BUS4)
D5: J2.19, U3.17 (D5), U5.17 (D5), U6.10 (BUS5)
D6: J2.18, U3.18 (D6), U5.18 (D6), U6.9 (BUS6)
D7: J2.17, U3.19 (D7), U5.19 (D7), U6.8 (BUS7)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, H1.1, H2.1, J1.1, J2.39, J2.40, U1.7 (GND), U1.9, U2.7 (GND), U2.9, U2.13, U3.14 (GND), U4.3 (K), U4.11 (GND), U5.14 (GND), U6.20 (VSS), U7.1 (OE), U7.10 (GND), U8.4 (E1), U8.5 (E2), U8.8 (GND)
HI: R3.2, U1.1, U1.2, U1.4, U1.5, U4.14 (J), U8.6 (E3)
unnamed: D1.1 (K), JP3.2, JP4.2, U1.8
unnamed: D1.2 (A), R1.2
unnamed: D2.2 (A), R2.2
unnamed: JP1.2, U3.27 (~WE)
unnamed: JP2.2, U5.27 (~WE)
unnamed: U1.12, U2.10
unnamed: U2.2, U3.20 (~CS)
unnamed: U2.4, U4.10 (K)
unnamed: U4.2 (~R), U4.9 (Q)
unnamed: U4.6 (~R), U4.13 (~Q)
Q: J2.7, U2.5, U6.4 (Q)
SC0: J2.11, U6.6 (SC0)
SC1: J2.9, U6.5 (SC1)
TPA: J2.14, U4.5 (C), U6.34 (TPA), U7.11 (LE)
TPB: J2.16, U2.11, U4.1 (C), U6.33 (TPB)
VCC: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, J1.3, J2.1, J2.2, JP1.1, JP2.1, R1.1, R2.1, R3.1, R4.1, U1.14 (VCC), U2.14 (VCC), U3.28 (VCC), U4.4 (VCC), U5.28 (VCC), U6.16 (VCC), U6.40 (VDD), U7.20 (VCC), U8.16 (VCC)
~CLEAR: J2.5, U6.3 (~CLEAR)
~DMA_IN: J2.6, U6.38 (~DMA_IN)
~DMA_OUT: J2.8, U6.37 (~DMA_OUT)
~EF1: J2.35, U6.24 (~EF1)
~EF2: J2.36, U6.23 (~EF2)
~EF3: J2.37, U6.22 (~EF3)
~EF4: J2.38, JP4.1, U6.21 (~EF4)
~INTERRUPT: J2.10, JP3.1, U6.36 (~INTERRUPT)
~IOR: J2.26, U4.8 (~Q)
~IOW: J2.25, U1.11
~MRD: J2.13, U1.13, U2.3, U3.22 (~OE), U4.7 (J), U5.22 (~OE), U6.7 (~MRD)
~MWR: J2.12, JP1.3, JP2.3, U6.35 (~MWR)
~N1: J2.33, U8.14 (O1)
~N2: J2.32, U8.13 (O2)
~N3: J2.31, U8.12 (O3)
~N4: J2.30, U8.11 (O4)
~N5: J2.29, U8.10 (O5)
~N6: J2.28, U8.9 (O6)
~N7: J2.27, U8.7 (O7)
~WAIT: J2.3, U6.2 (~WAIT)

Notes on the sheet:
Backplane Connector

Board: 2 copper layers, 100.0 x 100.0 mm, 31 parts (0 on the bottom side), 69 nets.

## KiCad design Prototype Adapter/Prototype Adapter.kicad_pcb

Parts:
C1, C2: 4u7; CP_Radial_D5.0mm_P2.50mm
J1: Conn_02x20_Odd_Even; PinHeader_2x20_P2.54mm_Vertical
J2, J3: Conn_01x18_Male; PinHeader_1x18_P2.54mm_Vertical
J4, J5: Conn_02x02_Top_Bottom; PinHeader_2x02_P2.54mm_Vertical

Connections:
CLOCK: J1.4, J2.1
D0: J1.24, J2.11
D1: J1.23, J3.11
D2: J1.22, J2.10
D3: J1.21, J3.10
D4: J1.20, J2.9
D5: J1.19, J3.9
D6: J1.18, J2.8
D7: J1.17, J3.8
GND: C1.2, C2.2, J1.39, J1.40, J4.3, J4.4, J5.3, J5.4
Q: J1.7, J3.3
SC0: J1.11, J3.5
SC1: J1.9, J3.4
TPA: J1.14, J2.6
TPB: J1.16, J2.7
USER1: J1.34
USER2: J1.15
VCC: C1.1, C2.1, J1.1, J1.2, J4.1, J4.2, J5.1, J5.2
~CLEAR: J1.5, J3.2
~DMA_IN: J1.6, J2.2
~DMA_OUT: J1.8, J2.3
~EF1: J1.35, J3.17
~EF2: J1.36, J2.17
~EF3: J1.37, J3.18
~EF4: J1.38, J2.18
~INTERRUPT: J1.10, J2.4
~IOR: J1.26, J2.12
~IOW: J1.25, J3.12
~MRD: J1.13, J3.6
~MWR: J1.12, J2.5
~N1: J1.33, J3.16
~N2: J1.32, J2.15
~N3: J1.31, J3.15
~N4: J1.30, J2.14
~N5: J1.29, J3.14
~N6: J1.28, J2.13
~N7: J1.27, J3.13
~WAIT: J1.3, J3.1
