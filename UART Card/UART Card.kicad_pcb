# Repository Mark-Clegg/Elf-Cube (continued)

## KiCad design Prototype Adapter/Prototype Adapter.kicad_pcb (continued)

Board: 2 copper layers, 62.1 x 55.1 mm, 7 parts (4 on the bottom side), 36 nets.

## KiCad design Backplane/Backplane.kicad_pcb

Parts:
C1, C2: 100nF; C_Disc_D3.8mm_W2.6mm_P2.50mm
C3: 1uF; CP_Radial_D5.0mm_P2.50mm
C4: 10uF; CP_Radial_D5.0mm_P2.50mm
C5: 100uF; CP_Radial_D5.0mm_P2.50mm
D1: D; D_DO-35_SOD27_P7.62mm_Horizontal
H1: Hole1; MountingHole_3.2mm_M3_Pad_Via
H2: Hole2; MountingHole_3.2mm_M3_Pad_Via
H3: Hole3; MountingHole_3.2mm_M3_Pad_Via
H4: Hole4; MountingHole_3.2mm_M3_Pad_Via
J1: Conn_02x20_Odd_Even; PinSocket_2x20_P2.54mm_Horizontal
J2, J3, J4, J5, J6: Conn_02x20_Odd_Even; PinSocket_2x20_P2.54mm_Vertical
J7: Conn_02x20_Odd_Even; PinHeader_2x20_P2.54mm_Horizontal
J8: USB_B; USB_B_Lumberg_2411_02_Horizontal
J9: Barrel_Jack_MountingPin; BarrelJack_Horizontal
J10: Conn_01x02_Male; PinHeader_1x02_P2.54mm_Horizontal
JP1: 4MHz; PinHeader_1x02_P2.54mm_Vertical
JP2: 2MHz; PinHeader_1x02_P2.54mm_Vertical
JP3: 1MHz; PinHeader_1x02_P2.54mm_Vertical
JP4: USB/Power; PinHeader_1x03_P2.54mm_Vertical
R1, R2, R3, R4, R5, R6, R7, R8: 22K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R9, R10, R11, R12, R13, R14, R15, R16, R19: 47K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R17: 100R; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R18: 10K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
SW1: Reset; SW_PUSH_6mm
U1: 74LS73; DIP-14_W7.62mm
U2: 74LS14; DIP-14_W7.62mm
U3: L7805; TO-220-3_Horizontal_TabDown
X1: AEL9700CS 4MHz; Oscillator_DIP-14

Connections:
CLOCK: J1.4, J2.4, J3.4, J4.4, J5.4, J6.4, J7.4, U2.2
D0: J1.24, J2.24, J3.24, J4.24, J5.24, J6.24, J7.24, R1.2
D1: J1.23, J2.23, J3.23, J4.23, J5.23, J6.23, J7.23, R2.2
D2: J1.22, J2.22, J3.22, J4.22, J5.22, J6.22, J7.22, R3.2
D3: J1.21, J2.21, J3.21, J4.21, J5.21, J6.21, J7.21, R4.2
D4: J1.20, J2.20, J3.20, J4.20, J5.20, J6.20, J7.20, R5.2
D5: J1.19, J2.19, J3.19, J4.19, J5.19, J6.19, J7.19, R6.2
D6: J1.18, J2.18, J3.18, J4.18, J5.18, J6.18, J7.18, R7.2
D7: J1.17, J2.17, J3.17, J4.17, J5.17, J6.17, J7.17, R8.2
GND: C1.2, C2.2, C3.2, C4.2, C5.2, H1.1, H2.1, H3.1, H4.1, J1.39, J1.40, J2.39, J2.40, J3.39, J3.40, J4.39, J4.40, J5.39, J5.40, J6.39, J6.40, J7.39, J7.40, J8.4 (GND), J8.5 (Shield), J9.2, J10.2, SW1.2, U1.11 (GND), U2.5, U2.7 (GND), U2.9, U2.13, U3.2 (GND), X1.7 (GND)
unnamed: C3.1, R17.1, R18.2, U2.3
unnamed: C5.1, J9.1, U3.1 (IN)
unnamed: D1.1 (K), U2.10
unnamed: J8.1 (VBUS), JP4.1 (A)
unnamed: J10.1, R17.2, SW1.1
unnamed: JP1.1 (A), U1.1 (C), X1.8 (OUT)
unnamed: JP1.2 (B), JP2.2 (B), JP3.2 (B), U2.1
unnamed: JP2.1 (A), U1.3 (K), U1.5 (C), U1.12 (Q)
unnamed: JP3.1 (A), U1.9 (Q), U1.10 (K)
unnamed: JP4.3 (B), U3.3 (OUT)
unnamed: U1.7 (J), U1.8 (~Q)
unnamed: U1.13 (~Q), U1.14 (J)
unnamed: U2.4, U2.11
Q: J1.7, J2.7, J3.7, J4.7, J5.7, J6.7, J7.7
SC0: J1.11, J2.11, J3.11, J4.11, J5.11, J6.11, J7.11
SC1: J1.9, J2.9, J3.9, J4.9, J5.9, J6.9, J7.9
TPA: J1.14, J2.14, J3.14, J4.14, J5.14, J6.14, J7.14
TPB: J1.16, J2.16, J3.16, J4.16, J5.16, J6.16, J7.16
USB_D+: J2.15, J8.3 (D+)
USB_D-: J2.34, J8.2 (D-)
VCC: C1.1, C2.1, C4.1, J1.1, J1.2, J2.1, J2.2, J3.1, J3.2, J4.1, J4.2, J5.1, J5.2, J6.1, J6.2, J7.1, J7.2, JP4.2 (C), R1.1, R2.1, R3.1, R4.1, R5.1, R6.1, R7.1, R8.1, R9.1, R10.1, R11.1, R12.1, R13.1, R14.1, R15.1, R16.1, R18.1, R19.1, U1.2 (~R), U1.4 (VCC), U1.6 (~R), U2.14 (VCC), X1.14 (Vcc)
~CLEAR: D1.2 (A), J1.5, J2.5, J3.5, J4.5, J5.5, J6.5, J7.5, R19.2
~DMA_IN: J1.6, J2.6, J3.6, J4.6, J5.6, J6.6, J7.6, R10.2
~DMA_OUT: J1.8, J2.8, J3.8, J4.8, J5.8, J6.8, J7.8, R11.2
~EF1: J1.35, J2.35, J3.35, J4.35, J5.35, J6.35, J7.35, R13.2
~EF2: J1.36, J2.36, J3.36, J4.36, J5.36, J6.36, J7.36, R14.2
~EF3: J1.37, J2.37, J3.37, J4.37, J5.37, J6.37, J7.37, R15.2
~EF4: J1.38, J2.38, J3.38, J4.38, J5.38, J6.38, J7.38, R16.2
~INTERRUPT: J1.10, J2.10, J3.10, J4.10, J5.10, J6.10, J7.10, R12.2
~IOR: J1.26, J2.26, J3.26, J4.26, J5.26, J6.26, J7.26
~IOW: J1.25, J2.25, J3.25, J4.25, J5.25, J6.25, J7.25
~MRD: J1.13, J2.13, J3.13, J4.13, J5.13, J6.13, J7.13
~MWR: J1.12, J2.12, J3.12, J4.12, J5.12, J6.12, J7.12
~N1: J1.33, J2.33, J3.33, J4.33, J5.33, J6.33, J7.33
~N2: J1.32, J2.32, J3.32, J4.32, J5.32, J6.32, J7.32
~N3: J1.31, J2.31, J3.31, J4.31, J5.31, J6.31, J7.31
~N4: J1.30, J2.30, J3.30, J4.30, J5.30, J6.30, J7.30
~N5: J1.29, J2.29, J3.29, J4.29, J5.29, J6.29, J7.29
~N6: J1.28, J2.28, J3.28, J4.28, J5.28, J6.28, J7.28
~N7: J1.27, J2.27, J3.27, J4.27, J5.27, J6.27, J7.27
~WAIT: J1.3, J2.3, J3.3, J4.3, J5.3, J6.3, J7.3, R9.2

Notes on the sheet:
Mounting Holes
Base Expansion Port (In)
Base Expansion Port (Out)
Card Slot 1
Card Slot 2
Card Slot 3
Card Slot 4
Card Slot 5
Power On Reset
Power Supply
Clock Generator

Board: 2 copper layers, 100.0 x 100.0 mm, 48 parts (0 on the bottom side), 51 nets.

## Commit log

2021-02-15 Added PDF Schematics for Rev.1.0 boards
2021-02-26 Added Template project
2021-03-20 Initial skeleton of BIOS code
2021-03-20 Added KDevelop project files to .gitignore
2021-03-20 Preparation of code and data segments
2021-03-20 Updated Makefile
2021-05-09 Added jump vector table initialisation
2021-06-25 Added UART Card
2021-06-25 Updated .gitignore
2021-06-26 Finalised board layout
2021-06-28 Added PC Serial Cable pinout
